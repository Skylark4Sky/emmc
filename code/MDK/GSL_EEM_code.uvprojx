# Keil uVision project GSL_EEM_code.uvprojx, settings and files
target gsl_eem_code (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GSL_EEM_code
  AfterMake: fromelf.exe  --bin -o  ..\Bin\GSL_EEM_code.bin ..\MDK\Objects\GSL_EEM_code.axf
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\User;..\User\lcd;..\Libararies\CMSIS;..\Libararies\STM32F10x_StdPeriph_Driver\inc;..\Libararies\Cryptographic
  memory RVCT4: ROM 0x8002000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../Libararies/CMSIS/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libararies/CMSIS/: core_cm3.c system_stm32f10x.c
  group StdPeriphDriver
    ../Libararies/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_crc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c
  group LCD
    ../User/lcd/: GUI.c Lcd_Driver.c
  group Cryptographic
    ../Libararies/Cryptographic/: md5.c
  group User
    ../User/: gisunlink_delay.c gisunlink_eeprom.c gisunlink_energy_metering.c gisunlink_gpio.c gisunlink_key.c gisunlink_lcd.c gisunlink_network_module.c gisunlink_timer.c gisunlink_updata.c gisunlink_usart.c gisunlink_coms.c gisunlink_conf.c gisunlink_network_task.c gisunlink_system.c
  group App
    ../User/: gisunlink_app.c stm32f10x_it.c
