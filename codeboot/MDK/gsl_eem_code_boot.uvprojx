# Keil uVision project gsl_eem_code_boot.uvprojx, settings and files
target gsl_eem_code_boot (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: gsl_eem_code_boot
  AfterMake: fromelf.exe  --bin -o  ..\Bin\GSL_EEM_code_boot.bin ..\MDK\Objects\GSL_EEM_code_boot.axf
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Libararies\CMSIS;..\Libararies\STM32F10x_StdPeriph_Driver\inc;..\User
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../Libararies/CMSIS/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libararies/CMSIS/: core_cm3.c system_stm32f10x.c
  group StdPeriphDriver
    ../Libararies/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_rcc.c
  group User
    ../User/: gisunlink_app.c gisunlink_eeprom.c gisunlink_iap.c gisunlink_usart.c stm32f10x_it.c
